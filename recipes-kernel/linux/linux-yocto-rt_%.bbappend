require linux-yocto-intel-grand-ridge.inc
